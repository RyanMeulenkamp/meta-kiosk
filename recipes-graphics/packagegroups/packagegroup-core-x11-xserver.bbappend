
XSERVER = "xserver-xorg \
           xserver-xorg-extension-glx \
           xf86-video-fbdev \
           xf86-video-modesetting \
           "
